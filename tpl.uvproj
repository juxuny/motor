# Keil uVision project tpl.uvproj, settings and files
target stm32f103x (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: tpl +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/: main.c main.h STM32F10x.s stm32f10x_it.c x_stm32.c x_stm32.h usart.c usart.h TIM3_PWM.C TIM3_PWM.h stm32f10x_it.h
  group lib
    ../: STM32F10xR.LIB
